# Keil uVision project AssemblyC.uvprojx, settings and files
target workspace (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AssemblyC
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group C
    ./src/: Main.c TCB.c TCB.h
  group Assembly
    ./src/: startup_stm32f429xx.s AssemblyModule.h AssemblyModule.s SaveRegisters.s SaveRegisters.h
